options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: center_freq
    orient: Qt.Horizontal
    start: 867e6
    step: '1'
    stop: 869e6
    value: 868e6
  states: {}
- name: channel_spacing
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: channel_spacing
    orient: Qt.Horizontal
    start: '-1000000'
    step: '1'
    stop: '1000000'
    value: '-370900'
  states: {}
- name: cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: cutoff
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 1e6
    value: '165500'
  states: {}
- name: demodgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: demodgain
    orient: Qt.Horizontal
    start: '-1'
    step: '1'
    stop: '42'
    value: '4'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: (channel_spacing / 2) + (channel_spacing * .1)
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: offset
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.001'
    stop: '1.0'
    value: '-0.698'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '20'
    value: '-14'
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: width
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '160000'
    value: '100400'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demodgain
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: partac
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/4
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate,cutoff, width,  firdes.WIN_BLACKMAN, 6.76)
    type: ccc
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0,2,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 6,0,2,2
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
